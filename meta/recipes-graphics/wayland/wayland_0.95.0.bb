require wayland.inc

SRC_URI = "http://wayland.freedesktop.org/releases/wayland-0.95.0.tar.xz"
SRC_URI[md5sum] = "23d6bcd500db9d1bb13e9b89722331dc"
SRC_URI[sha256sum] = "a38b915ce294efb3f45d3c66ea21f8424aea676656eca93af0edcc5d55a1efcb"

PR = "r0"
